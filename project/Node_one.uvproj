# Keil uVision project Node_one.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Node_one +hex
  c flags: Optim=1
  c include: ..\Library\inc;..\Library\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    C:/Keil/ARM/Startup/ST/STM32F10x/: startup_stm32f10x_cl.s
  group Library
    ../Library/src/: can.c dma.c extention.c extint.c gpio.c i2c.c myspi.c nvic.c timer.c usart.c watchdog.c
